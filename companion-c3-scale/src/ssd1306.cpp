#include "ssd1306.h"

#include <Wire.h>
#include <string.h>

// Classic 5x7 ASCII font (a variant of the common character-LCD glyph set; see THIRD_PARTY.md
// for attribution), column-major, bit 0 = top pixel row, covers
// 0x20 ' ' .. 0x7E '~'.
static const uint8_t kFont5x7[95][SSD1306_CHAR_W] = {
    0x00, 0x00, 0x00, 0x00, 0x00,  // 0x20
    0x00, 0x00, 0x5F, 0x00, 0x00,  // 0x21
    0x00, 0x07, 0x00, 0x07, 0x00,  // 0x22
    0x14, 0x7F, 0x14, 0x7F, 0x14,  // 0x23
    0x24, 0x2A, 0x7F, 0x2A, 0x12,  // 0x24
    0x23, 0x13, 0x08, 0x64, 0x62,  // 0x25
    0x36, 0x49, 0x55, 0x22, 0x50,  // 0x26
    0x00, 0x05, 0x03, 0x00, 0x00,  // 0x27
    0x00, 0x1C, 0x22, 0x41, 0x00,  // 0x28
    0x00, 0x41, 0x22, 0x1C, 0x00,  // 0x29
    0x14, 0x08, 0x3E, 0x08, 0x14,  // 0x2A
    0x08, 0x08, 0x3E, 0x08, 0x08,  // 0x2B
    0x00, 0x50, 0x30, 0x00, 0x00,  // 0x2C
    0x08, 0x08, 0x08, 0x08, 0x08,  // 0x2D
    0x00, 0x60, 0x60, 0x00, 0x00,  // 0x2E
    0x20, 0x10, 0x08, 0x04, 0x02,  // 0x2F
    0x3E, 0x51, 0x49, 0x45, 0x3E,  // 0x30
    0x00, 0x42, 0x7F, 0x40, 0x00,  // 0x31
    0x42, 0x61, 0x51, 0x49, 0x46,  // 0x32
    0x21, 0x41, 0x45, 0x4B, 0x31,  // 0x33
    0x18, 0x14, 0x12, 0x7F, 0x10,  // 0x34
    0x27, 0x45, 0x45, 0x45, 0x39,  // 0x35
    0x3C, 0x4A, 0x49, 0x49, 0x30,  // 0x36
    0x01, 0x71, 0x09, 0x05, 0x03,  // 0x37
    0x36, 0x49, 0x49, 0x49, 0x36,  // 0x38
    0x06, 0x49, 0x49, 0x29, 0x1E,  // 0x39
    0x00, 0x36, 0x36, 0x00, 0x00,  // 0x3A
    0x00, 0x56, 0x36, 0x00, 0x00,  // 0x3B
    0x00, 0x08, 0x14, 0x22, 0x41,  // 0x3C
    0x14, 0x14, 0x14, 0x14, 0x14,  // 0x3D
    0x41, 0x22, 0x14, 0x08, 0x00,  // 0x3E
    0x02, 0x01, 0x51, 0x09, 0x06,  // 0x3F
    0x32, 0x49, 0x79, 0x41, 0x3E,  // 0x40
    0x7E, 0x11, 0x11, 0x11, 0x7E,  // 0x41
    0x7F, 0x49, 0x49, 0x49, 0x36,  // 0x42
    0x3E, 0x41, 0x41, 0x41, 0x22,  // 0x43
    0x7F, 0x41, 0x41, 0x22, 0x1C,  // 0x44
    0x7F, 0x49, 0x49, 0x49, 0x41,  // 0x45
    0x7F, 0x09, 0x09, 0x01, 0x01,  // 0x46
    0x3E, 0x41, 0x41, 0x51, 0x32,  // 0x47
    0x7F, 0x08, 0x08, 0x08, 0x7F,  // 0x48
    0x00, 0x41, 0x7F, 0x41, 0x00,  // 0x49
    0x20, 0x40, 0x41, 0x3F, 0x01,  // 0x4A
    0x7F, 0x08, 0x14, 0x22, 0x41,  // 0x4B
    0x7F, 0x40, 0x40, 0x40, 0x40,  // 0x4C
    0x7F, 0x02, 0x04, 0x02, 0x7F,  // 0x4D
    0x7F, 0x04, 0x08, 0x10, 0x7F,  // 0x4E
    0x3E, 0x41, 0x41, 0x41, 0x3E,  // 0x4F
    0x7F, 0x09, 0x09, 0x09, 0x06,  // 0x50
    0x3E, 0x41, 0x51, 0x21, 0x5E,  // 0x51
    0x7F, 0x09, 0x19, 0x29, 0x46,  // 0x52
    0x46, 0x49, 0x49, 0x49, 0x31,  // 0x53
    0x01, 0x01, 0x7F, 0x01, 0x01,  // 0x54
    0x3F, 0x40, 0x40, 0x40, 0x3F,  // 0x55
    0x1F, 0x20, 0x40, 0x20, 0x1F,  // 0x56
    0x7F, 0x20, 0x18, 0x20, 0x7F,  // 0x57
    0x63, 0x14, 0x08, 0x14, 0x63,  // 0x58
    0x03, 0x04, 0x78, 0x04, 0x03,  // 0x59
    0x61, 0x51, 0x49, 0x45, 0x43,  // 0x5A
    0x00, 0x00, 0x7F, 0x41, 0x41,  // 0x5B
    0x02, 0x04, 0x08, 0x10, 0x20,  // 0x5C
    0x41, 0x41, 0x7F, 0x00, 0x00,  // 0x5D
    0x04, 0x02, 0x01, 0x02, 0x04,  // 0x5E
    0x40, 0x40, 0x40, 0x40, 0x40,  // 0x5F
    0x00, 0x01, 0x02, 0x04, 0x00,  // 0x60
    0x20, 0x54, 0x54, 0x54, 0x78,  // 0x61
    0x7F, 0x48, 0x44, 0x44, 0x38,  // 0x62
    0x38, 0x44, 0x44, 0x44, 0x20,  // 0x63
    0x38, 0x44, 0x44, 0x48, 0x7F,  // 0x64
    0x38, 0x54, 0x54, 0x54, 0x18,  // 0x65
    0x08, 0x7E, 0x09, 0x01, 0x02,  // 0x66
    0x08, 0x14, 0x54, 0x54, 0x3C,  // 0x67
    0x7F, 0x08, 0x04, 0x04, 0x78,  // 0x68
    0x00, 0x44, 0x7D, 0x40, 0x00,  // 0x69
    0x20, 0x40, 0x44, 0x3D, 0x00,  // 0x6A
    0x00, 0x7F, 0x10, 0x28, 0x44,  // 0x6B
    0x00, 0x41, 0x7F, 0x40, 0x00,  // 0x6C
    0x7C, 0x04, 0x18, 0x04, 0x78,  // 0x6D
    0x7C, 0x08, 0x04, 0x04, 0x78,  // 0x6E
    0x38, 0x44, 0x44, 0x44, 0x38,  // 0x6F
    0x7C, 0x14, 0x14, 0x14, 0x08,  // 0x70
    0x08, 0x14, 0x14, 0x18, 0x7C,  // 0x71
    0x7C, 0x08, 0x04, 0x04, 0x08,  // 0x72
    0x48, 0x54, 0x54, 0x54, 0x20,  // 0x73
    0x04, 0x3F, 0x44, 0x40, 0x20,  // 0x74
    0x3C, 0x40, 0x40, 0x20, 0x7C,  // 0x75
    0x1C, 0x20, 0x40, 0x20, 0x1C,  // 0x76
    0x3C, 0x40, 0x30, 0x40, 0x3C,  // 0x77
    0x44, 0x28, 0x10, 0x28, 0x44,  // 0x78
    0x0C, 0x50, 0x50, 0x50, 0x3C,  // 0x79
    0x44, 0x64, 0x54, 0x4C, 0x44,  // 0x7A
    0x00, 0x08, 0x36, 0x41, 0x00,  // 0x7B
    0x00, 0x00, 0x7F, 0x00, 0x00,  // 0x7C
    0x00, 0x41, 0x36, 0x08, 0x00,  // 0x7D
    0x08, 0x08, 0x2A, 0x1C, 0x08,  // 0x7E
};

// SSD1306 command set (SH1106-compatible clones accept the same subset).
static const uint8_t kInitCmds[] = {
    0xAE,             // display off
    0xD5, 0x80,       // clock divide / oscillator
    0xA8, 0x1F,       // multiplex ratio = 32
    0xD3, 0x00,       // display offset
    0x40,             // start line 0
    0x8D, 0x14,       // charge pump enable
    0x20, 0x00,       // horizontal addressing mode
    0xA1,             // segment remap (column 0 = right)
    0xC8,             // COM scan direction (row 0 = bottom)
    0xDA, 0x02,       // COM pins for 128x32
    0x81, 0xCF,       // contrast
    0xD9, 0xF1,       // pre-charge
    0xDB, 0x40,       // VCOM deselect
    0xA4,             // resume from RAM
    0xA6,             // normal (non-inverted)
    0xAF,             // display on
};

Ssd1306::Ssd1306()
    : _present(false), _panelOn(true), _addr(0x3C), _contrast(0xCF) {
    memset(_buffer, 0, sizeof(_buffer));
}

void Ssd1306::command(uint8_t cmd) {
    Wire.beginTransmission(_addr);
    Wire.write((uint8_t)0x00);   // Co=0, D/C#=0 -> command
    Wire.write(cmd);
    Wire.endTransmission();
}

void Ssd1306::commands(const uint8_t* cmds, size_t count) {
    Wire.beginTransmission(_addr);
    Wire.write((uint8_t)0x00);
    Wire.write(cmds, (size_t)count);
    Wire.endTransmission();
}

void Ssd1306::setContrast(uint8_t contrast) {
    _contrast = contrast;
    command(0x81);
    command(contrast);
}

bool Ssd1306::begin(uint8_t sdaPin, uint8_t sclPin, uint8_t contrast) {
    _contrast = contrast;

    // Bring the bus up on OUR pins before probing: the core defaults would use
    // GPIO8/GPIO9 on the C3, and GPIO8 is the status LED on this board.
    Wire.begin(sdaPin, sclPin, 400000);
    delay(20);

    // The module may be strapped to 0x3C or 0x3D; probe both.
    static const uint8_t candidates[2] = {0x3C, 0x3D};
    for (uint8_t i = 0; i < 2; i++) {
        _addr = candidates[i];
        Wire.beginTransmission(_addr);
        if (Wire.endTransmission() == 0) {
            _present = true;
            break;
        }
    }
    if (!_present) {
        return false;
    }
    commands(kInitCmds, sizeof(kInitCmds));
    setContrast(contrast);
    _panelOn = true;
    clear();
    flush();
    Serial.printf("[oled] SSD1306 128x32 found at 0x%02X (SDA=%d SCL=%d)\n",
                  (unsigned)_addr, (unsigned)sdaPin, (unsigned)sclPin);
    return true;
}

void Ssd1306::displayOn(bool on) {
    if (on == _panelOn) return;
    _panelOn = on;
    command(on ? 0xAF : 0xAE);
}

void Ssd1306::clear() {
    memset(_buffer, 0, sizeof(_buffer));
}

void Ssd1306::setPixel(int x, int y, bool on) {
    if (x < 0 || y < 0 || x >= SSD1306_WIDTH || y >= SSD1306_HEIGHT) return;
    const uint16_t index = (uint16_t)(y / 8) * SSD1306_WIDTH + x;
    const uint8_t  mask  = (uint8_t)(1 << (y & 7));
    if (on) {
        _buffer[index] |= mask;
    } else {
        _buffer[index] &= (uint8_t)~mask;
    }
}

void Ssd1306::fillRect(int x, int y, int w, int h, bool on) {
    for (int dy = 0; dy < h; dy++) {
        for (int dx = 0; dx < w; dx++) {
            setPixel(x + dx, y + dy, on);
        }
    }
}

void Ssd1306::drawRect(int x, int y, int w, int h, bool on) {
    drawHLine(x, y, w, on);
    drawHLine(x, y + h - 1, w, on);
    for (int dy = 0; dy < h; dy++) {
        setPixel(x, y + dy, on);
        setPixel(x + w - 1, y + dy, on);
    }
}

void Ssd1306::drawHLine(int x, int y, int w, bool on) {
    for (int dx = 0; dx < w; dx++) {
        setPixel(x + dx, y, on);
    }
}

void Ssd1306::drawChar(int x, int y, char c, uint8_t scale, bool inverted) {
    if (scale < 1) scale = 1;
    if (scale > 2) scale = 2;
    if (c < 0x20 || c > 0x7E) c = '?';

    const uint8_t* glyph = kFont5x7[(uint8_t)c - 0x20];

    if (inverted) {
        fillRect(x, y, SSD1306_CHAR_W * scale, SSD1306_CHAR_H * scale, true);
    }
    for (uint8_t col = 0; col < SSD1306_CHAR_W; col++) {
        const uint8_t bits = glyph[col];
        for (uint8_t row = 0; row < SSD1306_CHAR_H; row++) {
            if ((bits >> row) & 1) {
                fillRect(x + col * scale, y + row * scale, scale, scale, !inverted);
            }
        }
    }
}

void Ssd1306::drawText(int x, int y, const char* text, uint8_t scale, bool inverted) {
    if (scale < 1) scale = 1;
    if (scale > 2) scale = 2;
    for (const char* p = text; *p != '\0'; p++) {
        drawChar(x, y, *p, scale, inverted);
        x += (SSD1306_CHAR_W + 1) * scale;
        if (x >= SSD1306_WIDTH) break;
    }
}

void Ssd1306::drawTextRight(int xRight, int y, const char* text, uint8_t scale, bool inverted) {
    const int width = (int)strlen(text) * (SSD1306_CHAR_W + 1) * scale - scale;
    drawText(xRight - width + 1, y, text, scale, inverted);
}

void Ssd1306::drawNumberRight(int xRight, int y, float value, uint8_t decimals,
                              uint8_t scale, bool showSign) {
    char buf[20];
    if (decimals > 3) decimals = 3;
    const uint32_t magnitude = (uint32_t)(value < 0.0f ? -value : value);
    if (decimals == 0) {
        snprintf(buf, sizeof(buf), showSign ? "%s%lu" : "%lu",
                 (value < 0.0f ? "-" : ""), (unsigned long)magnitude);
    } else {
        uint32_t divisor = 1;
        for (uint8_t i = 0; i < decimals; i++) divisor *= 10;
        snprintf(buf, sizeof(buf), showSign ? "%s%lu.%0*lu" : "%lu.%0*lu",
                 (value < 0.0f ? "-" : ""), (unsigned long)(magnitude / divisor),
                 (int)decimals, (unsigned long)(magnitude % divisor));
    }
    drawTextRight(xRight, y, buf, scale, false);
}

void Ssd1306::drawBattery(int x, int y, uint8_t pct) {
    if (pct > 100) pct = 100;
    const int w = 16;
    const int h = 8;
    drawRect(x, y, w, h, true);              // body
    fillRect(x + w, y + 2, 2, 4, true);     // + terminal
    const int inner = w - 4;
    const int filled = (pct * inner) / 100;
    fillRect(x + 2, y + 2, filled, h - 4, true);
}

void Ssd1306::pageAddress(int page) {
    command((uint8_t)(0xB0 | (page & 0x0F)));
}

void Ssd1306::columnAddress(int col) {
    command((uint8_t)(0x00 | (col & 0x0F)));
    command((uint8_t)(0x10 | ((col >> 4) & 0x0F)));
}

void Ssd1306::flush() {
    if (!_present || !_panelOn) return;

    command(0x21);        // column range 0..127
    command(0);
    command(SSD1306_WIDTH - 1);
    command(0x22);        // page range 0..3
    command(0);
    command(SSD1306_PAGES - 1);

    static const uint8_t kChunk = 32;
    for (uint8_t page = 0; page < SSD1306_PAGES; page++) {
        const uint16_t base = (uint16_t)page * SSD1306_WIDTH;
        for (uint8_t col = 0; col < SSD1306_WIDTH; col += kChunk) {
            const uint8_t len = (uint8_t)((SSD1306_WIDTH - col) < kChunk
                                          ? (SSD1306_WIDTH - col) : kChunk);
            Wire.beginTransmission(_addr);
            Wire.write((uint8_t)0x40);          // Co=0, D/C#=1 -> RAM data
            Wire.write(_buffer + base + col, len);
            Wire.endTransmission();
        }
    }
}
